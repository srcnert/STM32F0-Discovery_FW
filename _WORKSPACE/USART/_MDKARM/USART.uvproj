# Keil uVision project USART.uvproj, settings and files
target STM32F0xx (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F051R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: STM32F0X +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F0XX DEBUG_ENABLED ASSERT_DISABLED RTT_LOG_ENABLED HSI_VALUE=8000000
  c include: ..\..\..\components\ST\STM32F0xx\include;..\..\..\components\toolchain\cmsis\include;..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\..\..\Libraries\STM32F0xx_MyLibrary\inc;..\..\..\Libraries\common;..\..\..\Libraries\debug;..\..\..\Libraries\segger_rtt;..\..\..\Utilities\STM32F0-Discovery;..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ../src/: main.c stm32f0xx_it.c system_stm32f0xx.c
  group STM32F0-Discovery
    ../../../Utilities/STM32F0-Discovery/: stm32f0_discovery.c
  group STM32F0xx_StdPeriph_Driver
    ../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_rcc.c stm32f0xx_misc.c stm32f0xx_gpio.c stm32f0xx_syscfg.c stm32f0xx_exti.c
  group MDK-ARM
    ../../../components/startup/: startup_stm32f0xx_mdkarm.s
  group DEBUG
    ../../../Libraries/debug/: error_check.c error_check.h
    ../../../Libraries/common/: critical_state.c critical_state.h
  group SEGGER
    ../../../Libraries/segger_rtt/: rtt_log.h rtt_log.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group STM32F0xx_My_Library
    ../../../Libraries/STM32F0xx_MyLibrary/src/: my_gpio_drv.c my_usart_drv.c
    ../../../Libraries/STM32F0xx_MyLibrary/inc/: my_usart_drv.h
